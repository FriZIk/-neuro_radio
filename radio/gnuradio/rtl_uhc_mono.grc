options:
  parameters:
    author: bpqvg
    generate_options: qt_gui
    id: rtl_uhc_mono
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_dec
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: audio_rate
  id: variable_qtgui_range
  parameters:
    start: '24000'
    step: '1000'
    stop: '192000'
    value: '48000'
  states: {}
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '-3000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1000'
    stop: '1000000'
    value: '100000'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label0: 101.9e6
    label1: 104.4e6
    label2: 433.5e6
    num_opts: '3'
    option0: 101.9e6
    option1: 104.4e6
    option2: 433.5e6
    type: real
    value: 101.9e6
  states: {}
- name: quadrature
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1000'
    stop: '900000'
    value: '192000'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: '24000'
    step: '1000'
    stop: '4096000'
    value: '2048000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: '10000000'
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.05'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: quadrature
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '3'
    taps: channel_filter
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Sink
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: Waterfall Plot
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl_tcp=10.10.10.10:1234
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [dc_blocker_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fft_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', dc_blocker_xx_0, '0']
- [rtlsdr_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
