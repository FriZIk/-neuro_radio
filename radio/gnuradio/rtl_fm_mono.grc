options:
  parameters:
    generate_options: no_gui
    id: rtl_fm_mono
    output_language: python
  states: {}

blocks:
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '434.350'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable
  parameters:
    value: '1'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: short
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7355'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl_tcp=10.10.10.10:1234
    bb_gain0: '20'
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0'
    baseband_freq: '103000000'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_waterfallsink2_0
  id: wxgui_waterfallsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    dynamic_range: '100'
    fft_rate: '15'
    fft_size: '512'
    freqvar: None
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: Waterfall Plot
    type: complex
    win: None
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_short_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_throttle_0, '0', blocks_udp_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rtlsdr_source_0, '0', wxgui_fftsink2_0, '0']
- [rtlsdr_source_0, '0', wxgui_waterfallsink2_0, '0']

metadata:
  file_format: 1
