options:
  parameters:
    generate_options: no_gui
    id: rtl_fm
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 101.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/10
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: short
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '7355'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '64'
    interp: '15'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl_tcp=10.10.10.10:1234
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0'
    baseband_freq: '103000000'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FFT Plot
    type: complex
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {}
- name: wxgui_waterfallsink2_0
  id: wxgui_waterfallsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    dynamic_range: '100'
    fft_rate: '15'
    fft_size: '512'
    freqvar: None
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: Waterfall Plot
    type: complex
    win: None
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_udp_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', wxgui_fftsink2_0, '0']
- [rtlsdr_source_0, '0', wxgui_waterfallsink2_0, '0']

metadata:
  file_format: 1
